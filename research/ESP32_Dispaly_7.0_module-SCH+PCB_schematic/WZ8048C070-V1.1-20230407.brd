# Repository jackhumbert/mini_cooper_dashboard

File readme.md:

# Mini Cooper S / R53 Digital Dash

## Hardware

* 2006 Mini Cooper S
* [ESP32 7" screen](https://www.elecrow.com/esp32-display-7-inch-hmi-display-rgb-tft-lcd-touch-screen-support-lvgl.html)
* [CAN-to-Serial adapter](https://docs.longan-labs.cc/1030001/)

## Todo

- [ ] Gas price/fill-up data tracking
- [ ] Time elapsed during playback
- [ ] Scrubbable playback

## EAGLE design research/ESP32_Dispaly_7.0_module-SCH+PCB_schematic/WZ8048C070-V1.1-20230407.brd

Parts:
C1: 0.1uF/NC; DISCRETE_C0603
C2, C4, C13, C20, C22, C24, C33: 100nF; C0603
C3, C6, C8, C15, C18: 1uF; 0603
C5: 1uF; C0603
C7, C10, C19, C23, C42, C43: 22uF; 0805
C9, C17, C21, C26, C34, C35: 100nF; 0603
C11: 4.7uF; 0603
C12, C29, C30: 1uF; DISCRETE_C0603
C14, C16: 1nF; C0603
C25, C32: 47uF; 0805
C27, C28: 100NF; 0603
C31: 10uF; DISCRETE_C0603
C38, C39: 10uF; C0603
C40, C41: 1uF; 0805
C54: 4.7uF; DISCRETE_C0603
D1, D6: SS24B/SMB; 214AB
D2: BZT52C-18V; DISCRETE_SOD123
D3: SS24/SMB; 214AB
D4: BZT52C-8.2V; DISCRETE_SOD123
J1, J5: PH2.0WT-2PIN
J2: 7.0-DIANRONG-50PIN-0.5MM; 7.0-DAINRONG-50PIN-0.5MM
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J4: 2.54-4P-WOTIE
J7, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
K1, K4: BUTTON; 157SW
L1, L4: 5.6UH; CD54
L5: CD32_6.8uH; CD32
LED1: RED; DISCRETE_LED-0603
P2, P4: FPC-6PIN-0.5MM
Q1, Q2: BAT54S; SOT23-3
Q5: S8050; SPARKFUN_SOT23
Q30: PMOS-3401-4A; SOT-23
R1: 75K; DISCRETE_R0603
R2: 10.5K; DISCRETE_R0603
R3, R41, R42: 4.7K; DISCRETE_R0603
R4, R10, R12, R19, R25: 0R; DISCRETE_R0603
R5, R32, R35, R37, R39: 10K/NC; DISCRETE_R0603
R6, R7: 1K; DISCRETE_R0603
R8, R9, R71, R72: 22R; DISCRETE_R0603
R11: 100R; R0603
R13, R14: 5.1K; DISCRETE_R0603
R15, R16, R17, R18, R21, R23, R24, R33, R34, R36, R67: 10K; DISCRETE_R0603
R20: 45.3K; DISCRETE_R0603
R22: 100K; DISCRETE_R0603
R26, R38, R40: 0R; R0603
R27, R28: 47K; DISCRETE_R0603
R29: 10R 1%; DISCRETE_R0603
R31: 10K/NC; R0603
R50: 0R/NC; DISCRETE_R0603
R58: 10k; R0603
R172: 100K; R0603
SD1: HOLDER-MICROSD-9P; 9P-SMD-W/-RING
U1: RY3420; A_XBJ_SOT23-5
U2: ESP32-S; ESP32-S3
U4: MT9201; SOT23-6
U5: LP3318; LP3318_SOT23-5
U6: CH340C; SOP-16
U8: AO4407A_PMOS; SOP8
U11: NS4168-ESOP-8

Connections:
3V3: C2.1, C4.2, C5.1, C7.2, C8.2, C9.2, C12.2, C13.1, C20.1, C22.2, C26.1, C29.2, C30.2, C31.2, C32.2, C33.1, C54.2, J2.P$44 (DVDD), J4.2, J7.3, J10.3, L4.2, P2.5 (2), P4.5 (2), R3.2, R5.1, R10.1, R16.1, R17.1, R18.1, R20.1, R22.2, R23.1, R24.1, R25.1, R26.1, R32.2, R34.2, R36.2, R39.2, R41.2, R42.2, R67.1, SD1.4 (VDD), U2.2 (3V3), U6.4 (V3), U6.16 (VCC)
AVDD_10V: C10.2, C15.2, C17.2, D1.2 (-), J2.P$8 (AVDD), Q1.1, R1.1
BAT+: J1.P$1, U8.P$5 (5_D), U8.P$6 (6_D), U8.P$7 (7_D), U8.P$8 (8_D)
D+: J3.A6 (DP1), J3.B6 (DP2), R9.1
D-: J3.A7 (DN1), J3.B7 (DN2), R8.1
DCLK1: C1.2, J2.P$14 (DCLK), R38.2
ESP32_RESET: C11.1, J2.P$7 (RESET), K4.2, R18.2, R40.1, U2.3 (EN)
GND: C1.1, C2.2, C3.1, C4.1, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.1, C13.2, C14.2, C15.1, C16.2, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C29.1, C30.1, C31.1, C32.1, C33.2, C34.1, C35.1, C40.1, C41.1, C42.1, C43.1, C54.1, D2.+, D4.-, J1.P$2, J1.P$3, J1.P$4, J2.P$3 (GND3), J2.P$13 (GND2), J2.P$15 (GND1), J2.P$16 (R0), J2.P$17 (R1), J2.P$18 (R2), J2.P$24 (G0), J2.P$25 (G1), J2.P$32 (B0), J2.P$33 (B1), J2.P$34 (B2), J2.P$46 (GND), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$6, J3.P$7, J3.P$8, J3.P$9, J4.1, J5.P$3, J5.P$4, J7.4, J7.SS1, J7.SS2, J10.4, J10.SS1, J10.SS2, K1.1, K4.1, LED1.-, P2.4 (3), P2.7, P2.8, P4.4 (3), P4.7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
I2S_BCLK: R19.1, U11.3 (BCLK)
I2S_CTRL: R22.1, U11.1 (CTRL)
I2S_SDIN: R4.1, U11.4 (SDATA)
IO0_BOOT_CLK: K1.2, R38.1, U2.27 (IO0)
IO1_G7: J2.P$31 (G7), U2.39 (IO1)
IO2_LCD_BL_CTR: R11.2, U2.38 (IO2), U4.4 (4-EN)
IO3_G4: J2.P$28 (G4), U2.15 (IO3)
IO4_B7: J2.P$39 (B7), U2.4 (IO4)
IO5_B6: J2.P$38 (B6), U2.5 (IO5)
IO6_B5: J2.P$37 (B5), U2.6 (IO6)
IO7_B4: J2.P$36 (B4), U2.7 (IO7)
IO8_G5: J2.P$29 (G5), U2.12 (IO8)
IO9_G2: J2.P$26 (G2), U2.17 (IO9)
IO10_TF_CS: R67.2, SD1.2 (CS), U2.18 (IO10)
IO11_TF_SPI_MOSI/TP_DIN: R23.2, SD1.3 (DI), U2.19 (IO11)
IO12_TF_CLK/TP_CLK: SD1.5 (SCLK), U2.20 (IO12)
IO13_TF_SPI_MISO/TP_OUT: R24.2, SD1.7 (DO), U2.21 (IO13)
IO14_R3: J2.P$19 (R3), U2.22 (IO14)
IO15_B3: J2.P$35 (B3), U2.8 (IO15)
IO16_G6: J2.P$30 (G6), U2.9 (IO16)
IO17_I2S_SDIN: R4.2, U2.10 (IO17)
IO18_I2S_LRCLK: R12.2, U2.11 (IO18)
IO19_I2C_SDA: P2.2 (5), P4.2 (5), R41.1, U2.13 (IO19)
IO20_I2C_SCL: P2.1 (6), P4.1 (6), R42.1, U2.14 (IO20)
IO21_R4: J2.P$20 (R4), U2.23 (IO21)
IO38_D: J4.4, J7.1, P2.3 (4), P4.3 (4), R5.2, U2.31 (IO38)
IO39_HSYNC: J2.P$40 (HSYNC), U2.32 (IO39)
IO40_VSYNC: J2.P$41 (VSYNC), U2.33 (IO40)
IO41_DE: J2.P$42 (DE), U2.34 (IO41)
IO42-I2S_BCLK: R19.2, U2.35 (IO42)
IO45_R7: J2.P$23 (R7), R31.2, U2.26 (IO45)
IO46_G3: J2.P$27 (G3), U2.16 (IO46)
IO47_R5: J2.P$21 (R5), U2.24 (IO47)
IO48_R6: J2.P$22 (R6), U2.25 (IO48)
L/R: J2.P$12 (L/R), R34.1, R35.2
LCD_LEDA: C19.2, C21.2, D6.2 (-), J2.P$49 (LED-A), J2.P$50 (LED_A), U4.5 (5-OV)
LCD_LEDK: J2.P$47 (LED-K), J2.P$48 (LED_K), R29.1, U4.3 (3-FB)
LRCLK: R12.1, U11.2 (LRCLK)
unnamed: LED1.+, R3.1
unnamed: J2.P$45 (VCOM), R25.2
unnamed: C14.1, C38.1, J5.P$2
unnamed: J2.P$5 (VCOM1), R26.2
unnamed: C38.2, U11.8 (VOP)
unnamed: R1.2, R2.1, U5.3 (FB)
unnamed: C39.2, U11.5 (VON)
unnamed: C27.2, C28.2, D1.1 (+), L1.2, U5.1 (LX)
unnamed: C27.1, Q1.3
unnamed: J3.A5 (CC1), R13.2
unnamed: J2.P$43 (MODE), R36.1, R37.2
unnamed: L4.1, U1.3 (SW)
unnamed: J2.P$4 (DITHB), R39.1
unnamed: C16.1, C39.1, J5.P$1
unnamed: D6.1 (+), L5.2, U4.1 (1-SW)
unnamed: J3.B5 (CC2), R14.1
unnamed: R20.2, R21.1, U1.5 (FB)
unnamed: Q5.1 (B), R11.1, R58.2
unnamed: C28.1, Q2.3
unnamed: C35.2, Q1.2, R7.1
unnamed: C34.2, Q2.1, R6.1
unnamed: Q5.3 (C), Q30.1 (G), R172.2
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
unnamed: R16.2, SD1.1 (DATA2)
unnamed: R17.2, SD1.8 (DATA1)
RESET: P2.6 (1), P4.6 (1), R40.2
U/D: J2.P$11 (U/D), R32.1, R33.2
UART0_RXD0: J10.1, R72.1, U2.36 (RXD0)
UART0_TXD0: J10.2, R71.1, U2.37 (TXD0)
USB_D+: R9.2, U6.5 (UD+)
USB_D-: R8.2, U6.6 (UD-)
VBUS: D3.1 (+), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R15.2, U8.P$4 (4_G)
VDD: C24.1, C25.1, R10.2, R50.2, U11.6 (VDD)
VGH+18V: C40.2, D2.-, J2.P$10 (VGH), R7.2, R27.1
VGL-8.2V: C41.2, D4.+, J2.P$9 (VGL), R6.2, R28.1
VIN: C3.2, C6.2, C23.2, C42.2, D3.2 (-), L1.1, Q30.2 (S), R50.1, R172.1, U1.1 (EN), U1.4 (VIN), U5.4 (EN), U5.5 (VIN), U8.P$1 (1_S), U8.P$2 (2_S), U8.P$3 (3_S)
VIN2: C18.2, C43.2, L5.1, Q30.3 (D), U4.6 (6-VIN)

Notes on the sheet:
Vout=0.6*(R20/R21 +1)=3.3V
系统3.3V电源
UART0接口
主控 ESP32-S3-WROOM-1-N4R8
USB type-c座子
电池及控制电路
IO0: 低电平：下载启动 高电平：SPI启动
EN: 高电平：芯片使能； 低电平：芯片关闭。
USB转串口
IIS 功放:NS4168
TF Card
BOOT
RESET
POWER LED
LCD+TP 接口
电容屏TP
Iout=0.2/R29
L/R和U/D，预留上下拉
数据传输模式选择，预留上下拉
R37/R36选DE和H/V
Vout=0.6*(R20/R21 +1)=10V
正负压源
LCD恒流驱动
默认使用右边P4的触摸接口，如需更换使用左边P2触摸接口,BOM需要更改使用P2
默认使用右边P4的触摸接口，如需更换使用左边P2触摸接口,PCB的排线孔也要更改
HM3416H更换为RY3420

Board: 2 copper layers, 181.1 x 103.9 mm, 124 parts (1 on the bottom side), 84 nets.

Other parts of the board:
U$10: 7.0底框
U$15: 7.0板框
U$30: ELECROW-NEW

## Commit log

2023-10-25 add designs
2023-11-03 add stuff
2023-11-04 fonts
2023-11-05 adding more units
2023-11-05 remove some glitchyness
2023-11-07 add platformio
2023-11-08 simulator working
2023-11-09 close to working
2023-11-10 state update - working
2023-11-11 update dbc, etc
2023-11-11 struct update
2023-11-12 more data
2023-11-13 time, log stuff
2023-11-14 bad algo
2023-11-15 buffer stuff
2023-11-15 buffer
2023-11-15 more decoding
2023-11-16 mapping
2023-11-16 refactoring
2023-11-16 new needle
2023-11-17 more maps
2023-11-17 dbc updates
2023-11-17 stalk messages
2023-11-18 optimizing
2023-11-18 faster tach
2023-11-18 optional logging
2023-11-18 fix simulator
2023-11-18 some clean-up
2023-11-19 start theme stuff
2023-11-21 odometer
2023-11-21 working i think
2023-11-22 stability
2023-11-25 stability, cold temps
2023-11-25 steering module
2023-11-27 correct wheel dir
2023-11-27 add preview
2023-11-27 remove old fonts
2023-12-11 add working rasppi
2024-08-04 use time offset from sd card
2024-08-08 send time & temp to tiny screen
